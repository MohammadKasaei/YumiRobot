Commit message: fifth-order polynomial

File: objects/rack/urdf/rack_red.urdf (robot description, URDF)
Before this commit: robot cube_with_handles, 5 links, 4 joints
Links:
- link main_surf: mass 0.01 -> 0.2
